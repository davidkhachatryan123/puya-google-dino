# Keil uVision project GoogleDino.uvprojx, settings and files
target GoogleDino (6240000::V6.24::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) IROM2(0x1FFF0080,0x00000010) XROM(0x1FFF0280,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GoogleDino +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: .\Application\User\Inc;.\Drivers\PY32F002B_HAL_Driver\Inc;.\Libraries\ssd1306
  memory RVCT1: ROM 0x1fff0280 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT5: ROM 0x1fff0080 size 0x10
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Application/User
    ./Application/User/Inc/: main.h py32f002b_hal_conf.h py32f002b_it.h
    ./Application/User/Src/: main.c py32f002b_hal_msp.c py32f002b_it.c
  group Drivers/PY32F002B_HAL_Driver
    ./Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_cortex.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c
  group Libraries/SSD1306
    ./Libraries/SSD1306/: ssd1306.h ssd1306.c
software components: CMSIS:CORE 6.4.0, Device:Startup 1.0.0
